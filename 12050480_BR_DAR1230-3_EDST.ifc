Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-04-20T10:08:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 20 10:08:42 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\964db3cf-6978-45e7-badb-45a536a43277\7b2d131e-4760-4c7e-a6ef-085d415cf599\ifc * Database version: 5507 * Database creation date: Wed Apr 20 10:08:38 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 20 10:08:39 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 20 10:08:39 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12050480_BR_DAR1230-3_EDST:28123051_BR_12050480_DAR1230-3_EDST, (2)
In: Default
Type - Material: z_Miele_Design_Glass
Type - Pset_BuildingElementProxyCommon - Reference: 28123051_BR_12050480_DAR1230-3_EDST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28123051_BR_12050480_DAR1230-3_EDST
Material: z_Miele_Design_Glass, z_Miele_Design_CLST, Aluminum, Poche, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 1218 mm; Height: 617 mm; Depth: 611 mm

# IfcDistributionPort, Port_354669
Description: Flow; FlowDirection: SOURCEANDSINK
